# Repository tebl/C64-Pi1541-II

File README.md:

# C64 PI1541-II
Well... if you're here, then that new and shiny SD2IEC wasn't cycle-exact enough for you? Sure, there are great FPGA-based solutions available at a premium, but for those of us on a tight budget or simply want to build it ourselves there is the excellent Pi1541-software with a Raspberry Pi 3 at its core!

A Pi1541 can be constructed in many ways, but even though you can easily build one without the help of a PCB such as the ones provided by this project - I've found it a lot easier to make them work when you have a PCB available. I've released the design files for a more traditional Raspberry Pi-hat if you would rather build one of those, these can be found in my old repository at [C64-Pi1541-Module](https://github.com/tebl/C64-Pi1541-Module). With this version I've attempted to make one that is a little easier on the eyes, as well as attempting to hide most of the bare electronics so that it does not need to be handled directly.

Read on for instructions on how to construct a Pi1541-II module yourself - as can be seen from the images, the solution is composed of three separate PCBs with most of the electronics mounted in the center. This creates a rudimentary case so that those without a functioning 3d-printer also have an acceptable alternative (the board is a little bit smaller than an actual floppy disk, but should be somewhat to scale). See https://cbm-pi1541.firebaseapp.com for any software-related information, this even includes instructions on how to construct a Pi1541 without a PCB available.

# 1> BOM
This is the list of parts that you'd need in order to construct a Pi1541-II, most if not all should be readily available from your friendly neighbourhood electronics store if you should happen to have one available. For me, that means ebay since those disappeared in the 80s around here, but your mileage may wary (so may the friendliness).

Values in parenthesis are components can be be considered optional, but if you want to build it for yourself I higly recommend them as they only should only slightly increase the overall cost of doing this project. When ordering the PCBs you can order them via your favourite PCB fabrication company, but please consider using the provided URLs as doing so will help me cover some of the costs associated with PCB designs (at no extra cost to you).

Check out the gallery-section for a selection of images that can be used to identify ebay-listings which should work for this build. When in doubt however, look for a different listing if the information provided is limited.

## 1.1> Pi1541-II Module
| Reference                 | Item                                  | Count |
| ------------------------- | ------------------------------------- | ----- |
| Pi1541-II Module (PCB)    | Fabricate using Gerber files ([order](https://www.pcbway.com/project/shareproject/Commodore_64_Pi1541_II_Module.html?inviteid=88707))          |     1 |
| A1                        | 2x20 female pin header                |     1 |
|                           | Raspberry Pi 3B                       |     1 |
| BZ1                       | Buzzer (7mm pin spacing, 5mm OK)      |   (1) |
| C1                        | 100nF ceramic capacitor (5mm)         |     1 |
| D2                        | 5mm LED, green colour                 |     1 |
| D3                        | 5mm LED, red colour                   |    (1)|
| IC1 *                     | SSD1306 I2C OLED 128x64 (0.96")       |    (1)|
| IC2 **                    | 7406 (DIP-14)                         |     1 |
| IC3                       | 4ch I2C level converter module        |     1 |
| R1, R2                    | 1k Ohm resistor                       |     2 |
| R6,R7                     | 330 Ohm resistor                      |  1 (1)|
| J1                        | 2.1mm x 5.5mm barrel plug             |     1 |
| J2, J3                    | Female S-terminal 6pin DIN PCB        |  1 (1)|
| J4                        | 1x4 female pin header                 |     1 |
| SW1-SW5                   | 6x6x5mm right-angle momentary button  |     5 |

*) Provisions for installing an OLED display here only when a faceplate is not used, but this is only recommended as a budget-edition so it's there if you need it. 
**) There are unfortunately counterfeit 7406 chips floating around, the ones I've had the most success with has been marked 7406PC though a few SN7406 have also worked. See Pi1541 software homepage for instructions on how to verify that the IC installed is working properly (it'll usually work, but with some issues on loading software).

## 1.2> Pi1541-II Faceplate
Note that for the faceplate there may be several variants available to you, this is due to the differences in the displays available for purchase - the one to look for is sometimes described as the old or **original** 4 pin I2C 128x64 SSD1306 OLED-display (0.96"). You can refer to this [image](https://github.com/tebl/C64-Pi1541-II/raw/main/gallery/2020-11-06%2000.01.40.jpg) when ordering, from the ones I've bought it seems easier to look for the wider ribbon cable on the bottom of the displays.

| Reference                 | Item                                  | Count |
| ------------------------- | ------------------------------------- | ----- |
| Pi1541-II Faceplate (PCB) | Fabricate using Gerber files ([order](https://www.pcbway.com/project/shareproject/Commodore_64_Pi1541_II_Faceplate__variant_A_.html?inviteid=88707))          |     1 |
| IC1                       | SSD1306 I2C OLED 128x64 (0.96")       |     1 |
| J4                        | 1x4 extra long pin header             |     1 |

## 1.3> Pi1541-II Backplate
| Reference                 | Item                                  | Count |
| ------------------------- | ------------------------------------- | ----- |
| Pi1541-II Backplate (PCB) | Fabricate using Gerber files ([order](https://www.pcbway.com/project/shareproject/Commodore_64_Pi1541_II_Backplate.html?inviteid=88707))          |     1 |

## 1.4> Miscellaneous components
This is a suggested list of components used to screw together each of the PCBs, most of these you can find as part of a set on ebay (just search for "*M3 nylon assorted standoff kit*").

| Reference                 | Item                                  | Count |
| ------------------------- | ------------------------------------- | ----- |
|                           | M3x6mm nylon screw                    |     6 |
|                           | M3 nylon Hex nut                      |     6 |
|                           | M3x6mm Nylon Hex standoff             |     4 |
|                           | M3x10mm Nylon Hex standoff            |     2 |
|                           | M3x15mm Nylon Hex standoff            |     4 |

# 2> Building the Pi1541-II
Still with me so far and all components arrived from wherever you ordered them? Excellent. The final and last step is soldering it all together into something that'll work for you, but first a few obligatory notes about equipment requirements: you'll need a proper soldering iron, something that comes with an adjustable temperature and not the one you found out in the shed from the previous owner of your house (probably). If you can get hold on some 64/40 soldering tinm the one that has lead in it is highly preferable if you have the option to do so (can't buy them around here, so send me a roll if you can). Other than that, take it slowly and do some light dry-fitting to ensure that you know where everything is supposed to go before soldering things onto the PCBs (removing components is a lot harder that soldering them in, trust me on that one).

## 2.1> Pi1541-II Module
Starting with the module, solder into place the smaller components like the resistors, the one capacitor and the socket for the 7406 IC. Finally, add the larger components such as the connectors and momentary switches - usually it is easiest to tack it into place in one corner, heat up the component again and then adjust the fitting so that everything is on straight and lining up with the silkscreen illustrations. A piece of the IEC connector will conflict with the buzzer specified for use, just snip it off (we'll hide it under the faceplate anyway)!

Before long, you should have something that looks like the above. In order to add some strain-relief for the Raspberry Pi 3, I've screwed it into place using a couple M3x10mm nylon hex standoffs, two M3x6mm scres and two M3 hex nuts on the bottom. At each of the corners, use some M3x15mm standoffs and have them thread through the board and into four M3x6mm hex standoffs.

## 2.2> Pi1541-II Faceplate
The faceplate does not have that many components, but note that there may be several versions of the faceplates available - pick the one that corresponds to the display you've ordered. The connector on the top left corner (J4) is supposed to slot into the module PCB below it, so adjust the height of this **before** soldering it into place - ensuring a good connection between the PCBs.

The next step is taking care of the OLED display side of things, the first part you need to do is to note down the pin ordering shown on the front of the module. The reason you're doing thisis that some of the vendors will have displays where the VCC and GND are swapped around, something that'll instantly kill the display if you connect things the wrong way around. If the pin order is VCC/GND/SCL/SDA as shown above, then you need to short pads 2-3 on JP1 and JP2 (the square pad is pin 1, in case you were wondering).

The second step to all this is that most of the displays will already have some pin headers soldered in place, unfortunately on the wrong side - at least when you want to use it in a build like this. This can be solved by carefully heating one pin at a time, then push it gently against something metal like a pair of pliers in order to push it through. Mount the OLED module on the underside of the faceplate, try using some heat if you're having trouble pushing it into place - be patient though, the display is a piece of glass and it'll break if you use too much force. Install M2 screws and nuts to add some strain relief to it, this'll keep the display from being pushed into the unit.

## 2.3> Pi1541-II Backplate
The backplate is mostly only there for decoration as well as make sure that the user don't have to handle the electronics too much during use. There should already be some M3x6mm hex standoffs mounted on the bottom of the module, so the only remaining step is putting on the backplate and fixing it into place using the remaining four M3 hex nuts. Trim off any parts of the screws that poke through the nuts, that way you won't scratch up your designated play-area more than necessary.

## 2.4> Configuring the Pi1541-II
The Pi1541 is easily configured by downloading the latest binaries for the software from https://cbm-pi1541.firebaseapp.com, extract the archive to the root of the SD-card you want to use. Since the Pi1541-II is an option B build of the specified software you'll need to update some of the settings, this is done by editing the file called *options.txt* - the lines you'll need to use with the Pi1541-II specifically is as follows:
```
splitIECLines = 1
GraphIEC = 0

SoundOnGPIO = 1
soundOnGPIODuration = 200
soundOnGPIOFreq = 200

LCDName = ssd1306_128x64
LcdLogoName = 1541ii

i2cBusMaster = 1
i2cLcdAddress = 60
```

Most of these are just suggestions, but they are what I'm using and for the most part the should be considered a place to start (the first name is a must though, as are the I2C stuff).

## 2.5> Troubleshooting
Still here? Damn... something must have gone wrong then! As stated on the website belonging to the software itself, most problems are solved by ensuring that you are using a power supply that is powerful enough for the Raspberry Pi 3B - the one I'm using is a cheap 5A one, somehow they seem to be much more reliable than the USB-powered ones (which you can't use because that is one of the design choices made along the way). If it sort of works or appears to hang suddenly, you might have a power issue.

If it is not a power issue, does the display work? If it is completely dark, take the Pi out of the Pi1541-II and allow it to start up - tune into it via HDMI to ensure that the Pi1541 software boots correctly. If it doesn't, check your SD-card.

Put it back in again, still now display and you've also checked that the configuration is correct? Double-check your previous notes so that you've soldered JP1/JP2 on the faceplate according to the actual pin order - if you've forgotten to do so, then do it now and try again. Did you do it the wrong way around and have already attempted to power up the thing, you know you probably did if you're here right now... In which case, you should order a new display since the one you own is probably completely dead by now.

You've gotten this far, then that's super-awesome! Hopefully you can select a d64 file from your SD-card, move up/down to the file and click select to start emulating a drive with that disk inserted. Try to load up the directory listing from your Commodore 64:
```
LOAD "$",8
```
If it fails instantly with a message saying "*DEVICE NOT PRESENT*", your 7406 might not be working as it should or possibly not at all (ensure your C64 actually works with the same cable and with a real disk drive first, if possible). Try a different chip and hope that it works.

If you get a different error or quite possibly the Commodore 64 just hangs there without doing anything, a good bet is that the I2C level converter is crappy - I've had around 20% DOA on those things, so it is not unlikely. My best recommendation is to use a multimeter and measure the resistance across various points, more than likely you can spot the one where nothing is connected by comparing between them (they usually come in packs of 5 or 10 so you should have spares).

Finally, if the computer just says *READY* then that is not an error - you just need to brush up on your BASIC commands. That's all I have, please feel free to join the C64 Facebook group if more assistance is needed (there's usually helpful people hanging around there).

## KiCad design C64 Pi1541-II FaceplateB/C64 Pi1541-II FaceplateB.kicad_pcb

Board: 2 copper layers, 97.8 x 97.8 mm, 8 parts (3 on the bottom side), 6 nets.

Parts:
IC1: 0.96_OLED; 0.96_I2C_OLED_NEW
J4: Faceplate; Pin_Header_Straight_1x04_Pitch2.54mm
JP1: P1_GND; OLED_SEL
JP2: P2_VCC; OLED_SEL
M1, M2, M3, M4: Mounting; M3

Connections:
+3V3: J4.2, JP1.3, JP2.1
GND: J4.1, JP1.1, JP2.3
I2C_SCL: IC1.3, J4.3
I2C_SDA: IC1.4, J4.4
unnamed: IC1.1, JP1.2
unnamed: IC1.2, JP2.2

## KiCad design C64 Pi1541-II Module/C64 Pi1541-II Module.kicad_pcb

Parts:
A1: Raspberry PI; Raspberry_Pi_3B_Socketed_THT_FaceDown_MountingHoles
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 100nF; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1: 1n4001; D_DO-41_SOD81_P10.16mm_Horizontal
D2: DRIVE; LED_D5.0mm
D3: POWER; LED_D5.0mm
IC1: 0.96_OLED; 0.96_I2C_OLED
IC2: 7406; DIP-14_W7.62mm_LongPads
IC3: I2C LC; 4CH_I2C_Level_Converter
J1: DC IN; BARREL_JACK
J2, J3: C64_IEC
J4: Faceplate; Pin_Header_Straight_1x04_Pitch2.54mm
JP1: P1_GND; OLED_SEL
JP2: P2_VCC; OLED_SEL
M1, M2, M3, M4: Mounting; M3
R1, R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SELECT; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW2: UP; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW3: DOWN; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW4: EXIT; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW5: ADD; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS

Connections:
+3V3: A1.1 (3V3), IC3.3 (LV), J4.2, JP1.3 (B), JP2.1 (A), R6.2
+5V: A1.2 (5V), C1.1, IC2.14 (VCC), IC3.10 (HV), J1.1, R1.1, R2.1
C64_ATN: IC3.7 (HV4), J2.3, J3.3
C64_CLK: IC2.4 (2Y), IC3.8 (HV3), J2.4, J3.4, R2.2
C64_DATA: IC2.2 (1Y), IC3.11 (HV2), J2.5, J3.5, R1.2
C64_RST: IC3.12 (HV1), J2.6, J3.6
GND: A1.6 (GND), A1.9 (GND), A1.14 (GND), A1.20 (GND), A1.25 (GND), A1.30 (GND), A1.34 (GND), A1.39 (GND), BZ1.2 (+), C1.2, D2.1 (K), D3.1 (K), IC2.7 (GND), IC3.4 (GND), IC3.9 (GND), J1.2, J1.3, J2.2, J2.7, J2.8, J3.2, J3.7, J3.8, J4.1, JP1.1 (A), JP2.3 (B), SW1.1, SW2.1, SW3.1, SW4.1, SW5.1
I2C_SCL: A1.5 (SCL/GPIO3), IC1.3 (SCL), J4.3
I2C_SDA: A1.3 (SDA/GPIO2), IC1.4 (SDA), J4.4
unnamed: A1.33 (PWM1/GPIO13), BZ1.1 (-)
unnamed: D2.2 (A), R7.1
unnamed: D3.2 (A), R6.1
unnamed: IC1.1 (GND), JP1.2 (C)
unnamed: IC1.2 (VCC), JP2.2 (C)
RPI_ATN: A1.18 (GPIO24), IC3.6 (LV4)
RPI_CLK_IN: A1.37 (GPIO26), IC3.5 (LV3)
RPI_CLK_OUT: A1.11 (GPIO17), IC2.3 (2A)
RPI_DATA_IN: A1.22 (GPIO25), IC3.2 (LV2)
RPI_DATA_OUT: A1.12 (GPIO18/PWM0), IC2.1 (1A)
RPI_LED: A1.36 (GPIO16), R7.2
RPI_RST: A1.38 (GPIO20/MOSI1), IC3.1 (LV1)
SW1: A1.13 (GPIO27), SW1.2
SW2: A1.15 (GPIO22), SW2.2
SW3: A1.16 (GPIO23), SW3.2
SW4: A1.7 (GCLK0/GPIO4), SW4.2
SW5: A1.29 (GCLK1/GPIO5), SW5.2

Notes on the sheet:
Wanted to do a revised version of the PI1541 module I made some time ago, but since I can't go smaller with my current equipment I made it ridiculously large instead. Intended for use with a faceplate and should for the most part look somewhat like a floppy disk (except a little smaller).

Board: 2 copper layers, 97.8 x 97.8 mm, 27 parts (0 on the bottom side), 26 nets.

## Commit log

2020-06-13 Initial base module
2020-06-18 Changed dimensions on module
2020-06-19 Faceplate
2020-06-19 Backplate
2020-06-19 Added DIN cutout
2020-09-27 Tweaked faceplate cutouts
2020-09-27 Module silkscreen tweaks
2020-10-01 Moved display slightly, remove soldermask from back layer.
2020-10-01 Removed diode
2020-10-01 Increased mounting hole size
2020-10-01 Added missing oled mounting hole
2020-10-01 Added copper layer to backplate
2020-10-01 Updated schematics
2020-10-01 Added gallery images
2020-10-02 Added README
2020-10-11 Updated PCBway links
2020-11-05 Added parts pictures to gallery
2020-11-06 Added faceplate B (new oled)
2021-01-11 Error in documentation
2021-01-11 Updated gerber files
2021-01-12 Adapted some of the input from Cologran, revision C of the main module.
2021-01-22 Tweaked faceplate B to better fit OLED mounting

Notices in the files:
C64 Pi1541-II FaceplateB/C64 Pi1541-II FaceplateB.kicad_pcb:
Licensed under
CERN OHL v.1.2
